# IAR project ble_app_hrs_freertos_s130_spi_5W_pca10028.ewp, settings and files
configuration nrf51422_xxac_s130 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SPI_MASTER_0_ENABLE; BLE_STACK_SUPPORT_REQD; __STACK_SIZE=2048; __HEAP_SIZE=1024; SWI_DISABLE3; S130; SVCALL_AS_NORMAL_FUNCTION; BOARD_PCA10028; NRF51; FREERTOS
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_hrs_freertos_s130_spi_5W_pca10028; ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\drivers_nrf\ble_flash; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\spi_master; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\mailbox; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\serialization\application\codecs\s130\serializers; ..\..\..\..\..\..\components\serialization\application\hal; ..\..\..\..\..\..\components\serialization\application\transport; ..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\components\serialization\common\struct_ser\s130; ..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\external\freertos\portable\IAR\nrf51; ..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf51; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\ble_app_hrs_freertos_s130_spi_5W_pca10028; ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\drivers_nrf\ble_flash; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\spi_master; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\mailbox; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\serialization\application\codecs\s130\serializers; ..\..\..\..\..\..\components\serialization\application\hal; ..\..\..\..\..\..\components\serialization\application\transport; ..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\components\serialization\common\struct_ser\s130; ..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\external\freertos\portable\IAR\nrf51; ..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf51
  OBJCOPY.OOCOutputFile: ble_app_hrs_freertos_s130_spi_5W_pca10028.hex
  ILINK.IlinkOutputFile: ble_app_hrs_freertos_s130_spi_5W_pca10028.out
  ILINK.IlinkIcfFile: ble_app_hrs_freertos_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Serialization
    ../../../../../../components/serialization/application/codecs/s130/serializers/: app_ble_gap_sec_keys.c app_ble_user_mem.c ble_enable.c ble_event.c ble_evt_tx_complete.c ble_evt_user_mem_release.c ble_evt_user_mem_request.c ble_gap_address_get.c ble_gap_address_set.c ble_gap_adv_data_set.c ble_gap_adv_start.c ble_gap_adv_stop.c ble_gap_appearance_get.c ble_gap_appearance_set.c ble_gap_auth_key_reply.c ble_gap_authenticate.c ble_gap_conn_param_update.c ble_gap_conn_sec_get.c ble_gap_connect.c ble_gap_connect_cancel.c ble_gap_device_name_get.c ble_gap_device_name_set.c ble_gap_disconnect.c ble_gap_encrypt.c ble_gap_evt_adv_report.c ble_gap_evt_auth_key_request.c ble_gap_evt_auth_status.c ble_gap_evt_conn_param_update.c ble_gap_evt_conn_param_update_request.c ble_gap_evt_conn_sec_update.c ble_gap_evt_connected.c ble_gap_evt_disconnected.c ble_gap_evt_passkey_display.c ble_gap_evt_rssi_changed.c ble_gap_evt_scan_req_report.c ble_gap_evt_sec_info_request.c ble_gap_evt_sec_params_request.c ble_gap_evt_sec_request.c ble_gap_evt_timeout.c ble_gap_ppcp_get.c ble_gap_ppcp_set.c ble_gap_rssi_get.c ble_gap_rssi_start.c ble_gap_rssi_stop.c ble_gap_scan_start.c ble_gap_scan_stop.c ble_gap_sec_info_reply.c ble_gap_sec_params_reply.c ble_gap_tx_power_set.c ble_gattc_char_value_by_uuid_read.c ble_gattc_char_values_read.c ble_gattc_characteristics_discover.c ble_gattc_descriptors_discover.c ble_gattc_evt_char_disc_rsp.c ble_gattc_evt_char_val_by_uuid_read_rsp.c ble_gattc_evt_char_vals_read_rsp.c ble_gattc_evt_desc_disc_rsp.c ble_gattc_evt_hvx.c ble_gattc_evt_prim_srvc_disc_rsp.c ble_gattc_evt_read_rsp.c ble_gattc_evt_rel_disc_rsp.c ble_gattc_evt_timeout.c ble_gattc_evt_write_rsp.c ble_gattc_hv_confirm.c ble_gattc_primary_services_discover.c ble_gattc_read.c ble_gattc_relationships_discover.c ble_gattc_write.c ble_gatts_characteristic_add.c ble_gatts_descriptor_add.c ble_gatts_evt_hvc.c ble_gatts_evt_rw_authorize_request.c ble_gatts_evt_sc_confirm.c ble_gatts_evt_sys_attr_missing.c ble_gatts_evt_timeout.c ble_gatts_evt_write.c ble_gatts_hvx.c ble_gatts_include_add.c ble_gatts_rw_authorize_reply.c ble_gatts_service_add.c ble_gatts_service_changed.c ble_gatts_sys_attr_get.c ble_gatts_sys_attr_set.c ble_gatts_value_get.c ble_gatts_value_set.c ble_l2cap_cid_register.c ble_l2cap_cid_unregister.c ble_l2cap_evt_rx.c ble_l2cap_tx.c ble_opt_get.c ble_opt_set.c ble_tx_buffer_count_get.c ble_user_mem_reply.c ble_uuid_decode.c ble_uuid_encode.c ble_uuid_vs_add.c ble_version_get.c power_system_off.c temp_get.c
    ../../../../../../components/serialization/application/codecs/s130/middleware/: app_mw_ble.c app_mw_ble_gap.c app_mw_ble_gattc.c app_mw_ble_gatts.c app_mw_ble_l2cap.c app_mw_nrf_soc.c
    ../../../../../../components/serialization/common/struct_ser/s130/: ble_gap_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c
    ../../../../../../components/serialization/application/hal/: ser_app_hal_nrf51.c ser_app_power_system_off.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_nrf51_spi_5W_master.c
    ../../../../../../components/serialization/application/transport/: ser_sd_transport.c ser_softdevice_handler.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/mailbox/: app_mailbox.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/IAR/nrf51/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf51/: port_cmsis.c port_cmsis_systick.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage_nosd.c
    ../../../../../../components/drivers_nrf/spi_master/: spi_5W_master.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
