# IAR project ble_app_hrs_s310_with_dfu_pca10028.ewp, settings and files
configuration nrf51422_xxac_s310 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_DFU_APP_SUPPORT; BLE_STACK_SUPPORT_REQD; S310; BOARD_PCA10028; SWI_DISABLE0; SOFTDEVICE_PRESENT; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_hrs_s310_with_dfu_pca10028; ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\libraries\bootloader_dfu; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s310\headers; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\ble_app_hrs_s310_with_dfu_pca10028; ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\libraries\bootloader_dfu; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s310\headers
  OBJCOPY.OOCOutputFile: ble_app_hrs_s310_with_dfu_pca10028.hex
  ILINK.IlinkOutputFile: ble_app_hrs_s310_with_dfu_pca10028.out
  ILINK.IlinkIcfFile: ble_app_hrs_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
