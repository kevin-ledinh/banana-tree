# Keil uVision project ant_scalable_encrypted_rx_s210_n5_starterkit.uvproj, settings and files
target nrf51422_xxaa (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD S210 BOARD_N5DK1 ANT_ENCRYPT_SLAVE_NEGOTIATION_USED NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\config\ant_scalable_encrypted_rx_s210_n5_starterkit;..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\ant\ant_encryption;..\..\..\..\..\..\components\ant\ant_search_config;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s210\headers
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group Application
    ../../: ant_scalable_encrypted_rx.c main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_encryption/: ant_encrypt_config.c ant_encrypt_negotiation_slave.c
    ../../../../../../components/ant/ant_search_config/: ant_search_config.c
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s210_nrf51422_5.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: s210_nrf51422_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\config\ant_scalable_encrypted_rx_s210_n5_starterkit;..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain
  asm define: ANT_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
