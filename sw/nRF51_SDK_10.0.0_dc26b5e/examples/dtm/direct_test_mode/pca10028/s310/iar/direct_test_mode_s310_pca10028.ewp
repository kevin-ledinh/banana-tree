# IAR project direct_test_mode_s310_pca10028.ewp, settings and files
configuration nrf51422_xxac_s310 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; S310; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\config\direct_test_mode_s310_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s310\headers; ..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\direct_test_mode_s310_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s310\headers; ..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: direct_test_mode_s310_pca10028.hex
  ILINK.IlinkOutputFile: direct_test_mode_s310_pca10028.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
  group Documentation
    ../../../: Abstract.txt license.txt
