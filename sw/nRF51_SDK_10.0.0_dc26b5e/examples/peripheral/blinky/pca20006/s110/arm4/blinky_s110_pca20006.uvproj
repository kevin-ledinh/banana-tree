# Keil uVision project blinky_s110_pca20006.uvproj, settings and files
target nrf51822_xxaa_s110 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51822_xxaa_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BSP_DEFINES_ONLY BOARD_PCA20006 S110 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config\blinky_s110_pca20006;..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\bsp;..\..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
