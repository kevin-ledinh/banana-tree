# IAR project blinky_s110_pca20006.ewp, settings and files
configuration nrf51822_xxaa_s110 (ARM)
  General.OGChipSelectEditMenu: nrf51822_xxaa nRF51822_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BSP_DEFINES_ONLY; BOARD_PCA20006; S110; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\config\blinky_s110_pca20006; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s110\headers; ..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\blinky_s110_pca20006; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s110\headers; ..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: blinky_s110_pca20006.hex
  ILINK.IlinkOutputFile: blinky_s110_pca20006.out
  ILINK.IlinkIcfFile: blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
