# Keil uVision project blinky_blank_pca20006.uvproj, settings and files
target nrf51822_xxaa (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51822_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA20006 NRF51
  c misc: --c99
  c include: ..\..\..\config\blinky_blank_pca20006;..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\bsp;..\..\..
  asm define: BSP_DEFINES_ONLY BOARD_PCA20006 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
