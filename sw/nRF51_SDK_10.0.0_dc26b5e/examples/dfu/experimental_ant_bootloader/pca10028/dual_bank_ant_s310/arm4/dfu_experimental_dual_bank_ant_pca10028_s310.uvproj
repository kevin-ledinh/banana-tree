# Keil uVision project dfu_experimental_dual_bank_ant_pca10028_s310.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S310 SWI_DISABLE0 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config\dfu_experimental_dual_bank_ant_pca10028_s310;..\..\..\config;..\..\..\include;..\..\..\include\boot_common;..\..\..;..\..\..\..\..\bsp;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\libraries\ant_fs;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s310\headers
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3b800 size 0x4800
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: antfs_ota.c bootloader.c bootloader_util_arm.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/ant_fs/: antfs.c crc.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
